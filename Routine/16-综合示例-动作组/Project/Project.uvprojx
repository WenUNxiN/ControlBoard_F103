# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: D:\Company_Project\课程资料\ControlBoard_F103\Routine\16-综合示例-动作组\Project\keil5_disp_size_bar.exe
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Library;..\Library\Start;..\System;..\User;..\App;..\BSP;..\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c main.h
  group App
    ../App/: Global.c Application.c Action.c App_Ps2.c Protocol.c ServoPID.c Kinematics.c Function.c protocolConversion.c
  group BSP
    ../BSP/: OLED.c bmp.h OLED.h OLEDFont.h Ultrasonic.c GY33T.c joystick.c
  group Hardware
    ../Hardware/: PwmServo.c Uart.c Beep.c Key.c Led.c Ps2.c SPI_Flash.c Soft_I2C.c Soft_I2C.h
  group System
    ../System/: rcc.c sys.c SysTick.c Timer.c
  group Start
    ../Library/Start/: core_cm3.c startup_stm32f10x_md.s system_stm32f10x.c
  group Library
    ../Library/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
